# Keil uVision project STM32.uvprojx, settings and files
target STM32F103ZE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hex +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Lib\User;..\Lib\HW\inc;..\Lib\FW\inc;..\Lib\Core\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../Lib/User/: main.c stm32f10x_it.c stm32f10x_bsp.c stm32f10x_conf.h stm32f10x_it.h
  group HW
    ../Lib/HW/src/: LED.c Systick.c Beep.c
  group Core
    ../Lib/Core/src/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group FW
    ../Lib/FW/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c
  group Readme
    ../Readme/: Readme.txt
